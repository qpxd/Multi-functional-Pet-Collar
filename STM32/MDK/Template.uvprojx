# Keil uVision project Template.uvprojx, settings and files
target TEMPLATE (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,SYSTEM_FREERTOS_ENABLED
  c include: ..\DriverLayer;..\HelpLayer;..\PeripheralOnchip;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\ThirdPart\FreeRTOS\include;..\ThirdPart\FreeRTOS\portable\RVDS\ARM_CM3;..\ThirdPart\eMPL;..\ThirdPart\VL53L0\core\inc;..\ThirdPart\VL53L0\platform\inc;..\ThirdPart\FATFS;..\ThirdPart\FATFS\exfuns;..\AppLayer\app_demo;..\AppLayer\config;..\AppLayer\system;..\Libraries\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x14000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App/Demo
    ../AppLayer/app_demo/: my_app.c
  group App/System
    ../AppLayer/system/: delay.c int_manage.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c sys.c system_stm32f1xx.c startup_stm32f103xe.s
  group App/Config
    ../AppLayer/config/: app_conf.h driver_conf.h help_conf.h onchip_conf.h stm32f1xx_hal_conf.h FreeRTOSConfig.h
  group HelpLayer
    ../HelpLayer/: algorithm.c data_cut.c log.c my_pid.c reg.c my_list.h hash.c
  group PeripheralOnchip
    ../PeripheralOnchip/: chassis.c my_adc.c my_iic.c my_pwm.c my_spi.c my_timer.c my_uart.c smbus.c my_flash.c
  group ThirdPart/FreeRTOS
    ../ThirdPart/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../ThirdPart/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../ThirdPart/FreeRTOS/portable/MemMang/: heap_4.c
  group ThirdPart/eMPL
    ../ThirdPart/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group ThirdPart/VL53L0
    ../ThirdPart/VL53L0/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../ThirdPart/VL53L0/platform/src/: vl53l0x_platform.c
  group ThirdPart/FATFS
    ../ThirdPart/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
    ../ThirdPart/FATFS/exfuns/: exfuns.c
  group Libraries
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Driver
    ../DriverLayer/: key_board.c switch.c ds18b20.c esp8266.c gps.c mpu6050.c oled.c hc_sr04.c
